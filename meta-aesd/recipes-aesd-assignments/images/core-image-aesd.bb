inherit core-image
CORE_IMAGE_EXTRA_INSTALL += "aesd-assignments"
CORE_IMAGE_EXTRA_INSTALL += "aesd-char-driver"
CORE_IMAGE_EXTRA_INSTALL += "openssh"
inherit extrausers
